# Keil uVision project PY32F072xx.uvprojx, settings and files
target PY32F030xx_8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x3 Puya
  pack: Puya.PY32F0xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030xx_8 +hex
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F030xx_8 PY32F030x8
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target PY32F030xx_16 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x4 Puya
  pack: Puya.PY32F0xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030xx_16 +hex
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F030xx_16 PY32F030x8
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY32F030xx_32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x6 Puya
  pack: Puya.PY32F0xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030xx_32
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F030xx_32 PY32F030x8
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY32F030xx_48 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x7 Puya
  pack: Puya.PY32F0xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x0000C000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030xx_48
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F030xx_48 PY32F030x8
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY32F030xx_64 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030xx_64
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F030xx_64 PY32F030x8
  memory RVCT4: ROM 0x20000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OPT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x3 Puya
  pack: Puya.PY32F0xx_DFP.1.0.3
  cpu: as above
  output: PY32F030xx_OPT
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_OPT PY32F030x8
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY32F072xx_128 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.0.3
  cpu: as above
  output: PY32F030xx_8 +hex
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F072xB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
